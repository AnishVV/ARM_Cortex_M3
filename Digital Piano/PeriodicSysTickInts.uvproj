# Keil uVision project PeriodicSysTickInts.uvproj, settings and files
target PeriodicSysTickInts (ARM-ADS)
  device: LM3S1968 Luminary Micro
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x3FFFF) CLOCK(6000000) CPUTYPE("Cortex-M3")
  output: Main +hex
  AfterMake: c:\Keil\ARM\BIN40\fromelf.exe --bin .\Hex&Bin\PeriodicSysTickInts.axf --output .\Hex&Bin\ PeriodicSysTickInts.bin
  c flags: Optim=1
  c include: ..;..\..\..;..\inc;..\driverlib
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Code
    ./: Startup.s DAC.c PLL.c Sound.c Piano.c Test.c Main.c
  group Library
    ../driverlib/rvmdk/: driverlib.lib
