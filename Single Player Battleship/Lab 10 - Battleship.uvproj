# Keil uVision project Lab 10 - Battleship.uvproj, settings and files
target Lab 10 - Battleship (ARM-ADS)
  device: LM3S1968 Luminary Micro
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x3FFFF) CLOCK(6000000) CPUTYPE("Cortex-M3")
  output: Lab 10 - Battleship
  c flags: Optim=1
  c include: ..;..\..\..;..\inc;..\driverlib
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Code
    ./: Startup.s PLL.c Output.c rit128x96x4.c logo.c Battleship_Main.c GameSound.h DAC.h DAC.c Display.c Grid.c PortGInts.c Utils.c ADC.c ADC.h GameSound.c
    ./Sounds/: Sounds.h
  group Library
    ../driverlib/rvmdk/: driverlib.lib
  group Art
    ./Art/: BattleshipCover.c Battleships.c GridTiles.c Miss.c Menu.c Hit.c Lose.c Win.c
